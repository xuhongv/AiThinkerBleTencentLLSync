# Keil uVision project qcloud_iot.uvprojx, settings and files
target qcloud_iot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: qcloud_iot +hex
  AfterMake: fromelf.exe --bin -o  ./bin  ./Objects/qcloud_iot.axf
  AfterMake: fromelf.exe .\Objects\qcloud_iot.axf --i32combined --output .\bin\qcloud_iot.hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP CFG_QFN32 CFG_SLEEP_MODE=PWR_MODE_NO_SLEEP DEBUG_INFO=3 CFG_FLASH=4096  CFG_OTA_BANK_MODE=OTA_DUAL_BANK  USE_FCT=0
  c misc: -DADV_NCONN_CFG=0x01   -DADV_CONN_CFG=0x02   -DSCAN_CFG=0x04    -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02   -DPERIPHERAL_CFG=0x04   -DCENTRAL_CFG=0x08   -DHOST_CONFIG=0x4
  c include: ..\PHY62XX_SDK_2_1_0\components\inc;..\PHY62XX_SDK_2_1_0\components\common;..\PHY62XX_SDK_2_1_0\components\osal\include;..\PHY62XX_SDK_2_1_0\components\ble\include;..\PHY62XX_SDK_2_1_0\components\ble\hci;..\PHY62XX_SDK_2_1_0\components\ble\host;..\PHY62XX_SDK_2_1_0\components\ble\controller\include;..\PHY62XX_SDK_2_1_0\components\profiles\DevInfo;..\PHY62XX_SDK_2_1_0\components\profiles\GATT;..\PHY62XX_SDK_2_1_0\components\profiles\SimpleProfile;..\PHY62XX_SDK_2_1_0\components\profiles\Roles;..\PHY62XX_SDK_2_1_0\components\profiles\ota;..\PHY62XX_SDK_2_1_0\components\profiles\ota_app;..\PHY62XX_SDK_2_1_0\components\driver\common;..\PHY62XX_SDK_2_1_0\components\driver\log;..\PHY62XX_SDK_2_1_0\components\driver\gpio;..\PHY62XX_SDK_2_1_0\components\driver\pwrmgr;..\PHY62XX_SDK_2_1_0\components\driver\uart;..\PHY62XX_SDK_2_1_0\components\driver\clock;..\PHY62XX_SDK_2_1_0\components\driver\flash;..\PHY62XX_SDK_2_1_0\components\driver\adc;..\PHY62XX_SDK_2_1_0\components\driver\timer;..\PHY62XX_SDK_2_1_0\components\driver\kscan;..\PHY62XX_SDK_2_1_0\components\driver\i2c;..\PHY62XX_SDK_2_1_0\components\driver\spi;..\PHY62XX_SDK_2_1_0\components\driver\watchdog;..\PHY62XX_SDK_2_1_0\lib;.\Source;..\qcloud_iot_explorer_BLE\date_template;..\qcloud_iot_explorer_BLE\hal;..\qcloud_iot_explorer_BLE\inc;..\qcloud_iot_explorer_BLE\src\internal_inc
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\PHY62XX_SDK_2_1_0\misc\rom1Sym.txt --keep=jump_table_base  --keep=global_config
  group arch
    ./Source/: main.c
  group profile
    ../PHY62XX_SDK_2_1_0/components/profiles/GATT/: gattservapp.c
    ../PHY62XX_SDK_2_1_0/components/profiles/Roles/: gap.c gapgattserver.c peripheral.c gapbondmgr.c
    ../PHY62XX_SDK_2_1_0/components/profiles/ota/: ota_flash.c
  group jump
    ../PHY62XX_SDK_2_1_0/misc/: jump_table.c
  group app
    ./Source/: OSAL_qcloud.c qcloud.c qcloud_Main.c
  group rf
    ../PHY62XX_SDK_2_1_0/lib/: rf.lib
  group driver
    ../PHY62XX_SDK_2_1_0/components/driver/common/: common.c
    ../PHY62XX_SDK_2_1_0/components/driver/gpio/: gpio.c
    ../PHY62XX_SDK_2_1_0/components/driver/log/: my_printf.c
    ../PHY62XX_SDK_2_1_0/components/driver/uart/: uart.c
    ../PHY62XX_SDK_2_1_0/components/driver/pwrmgr/: pwrmgr.c
    ../PHY62XX_SDK_2_1_0/components/driver/clock/: clock.c
    ../PHY62XX_SDK_2_1_0/components/driver/flash/: flash.c
  group osal
    ../PHY62XX_SDK_2_1_0/components/osal/snv/: osal_snv.c
  group qcloud_iot_explorer
    ../qcloud_iot_explorer_BLE/src/core/: ble_qiot_service.c ble_qiot_llsync_data.c ble_qiot_llsync_device.c ble_qiot_llsync_event.c ble_qiot_llsync_ota.c ble_qiot_llsync_utils.c
    ../qcloud_iot_explorer_BLE/src/utils/: ble_qiot_utils_base64.c ble_qiot_utils_crc.c ble_qiot_utils_hmac.c ble_qiot_utils_log.c ble_qiot_utils_md5.c ble_qiot_utils_sha1.c
    ../qcloud_iot_explorer_BLE/date_template/: ble_qiot_template.c
  group unit
    ./Source/: macmanage.c ota.c mytimer.c triad.c
  group hal
    ../qcloud_iot_explorer_BLE/hal/: qcloud_iot.lib
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.1
